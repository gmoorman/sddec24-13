v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {8x8crossbar.sym} 560 -50 0 0 {name=x1}
