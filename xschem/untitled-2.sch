v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/kivimagi/reram/current_progress/xschem/2x2matrix.sym} -30 -10 0 0 {name=x1}
