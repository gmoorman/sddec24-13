v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1695 -4200 1925 -4200 {
lab=lsb16}
N 2113.125 -4230 2153.125 -4230 {
lab=Vo1}
N 2113.75 -4210 2153.75 -4210 {
lab=Vo1not}
N 1695 -4220 1695 -4200 {
lab=lsb16}
N 1695 -4200 1695 -4160 {
lab=lsb16}
N 1695 -3980 1695 -3951.25 {
lab=lsb14}
N 1695 -3951.25 1695 -3920 {
lab=lsb14}
N 1695 -3740 1695 -3711.25 {
lab=lsb12}
N 1695 -3711.25 1695 -3680 {
lab=lsb12}
N 1695 -3500 1695 -3473.75 {
lab=lsb10}
N 1695 -3473.75 1695 -3440 {
lab=lsb10}
N 1695 -3260 1695 -3228.75 {
lab=lsb8}
N 1695 -3228.75 1695 -3200 {
lab=lsb8}
N 1695 -3020 1695 -2991.25 {
lab=lsb6}
N 1695 -2991.25 1695 -2960 {
lab=lsb6}
N 1695 -2780 1695 -2751.25 {
lab=lsb4}
N 1695 -2751.25 1695 -2720 {
lab=lsb4}
N 1695 -2540 1695 -2511.25 {
lab=lsb2}
N 1695 -2511.25 1695 -2480 {
lab=lsb2}
N 1695 -4068.75 1695 -4040 {
lab=lsb15}
N 1695 -3591.25 1695 -3560 {
lab=lsb11}
N 1695 -4320 1695 -4280 {
lab=Vrefa}
N 1695 -4068.75 1925 -4068.75 {
lab=lsb15}
N 2111.25 -4098.75 2151.25 -4098.75 {
lab=Vo2}
N 2111.875 -4078.75 2151.875 -4078.75 {
lab=Vo2not}
N 1695 -3951.25 1925 -3951.25 {
lab=lsb14}
N 2111.875 -3981.25 2151.875 -3981.25 {
lab=Vo3}
N 2112.5 -3961.25 2152.5 -3961.25 {
lab=Vo3not}
N 1695 -3826.25 1925 -3826.25 {
lab=lsb13}
N 2112.5 -3856.25 2152.5 -3856.25 {
lab=Vo4}
N 2113.125 -3836.25 2153.125 -3836.25 {
lab=Vo4not}
N 1695 -3711.25 1925 -3711.25 {
lab=lsb12}
N 2112.5 -3741.25 2152.5 -3741.25 {
lab=Vo5}
N 2111.875 -3721.25 2150 -3721.25 {
lab=Vo5not}
N 1695 -3591.25 1925 -3591.25 {
lab=lsb11}
N 2111.875 -3601.25 2151.875 -3601.25 {
lab=Vo6not}
N 1695 -3473.75 1925 -3473.75 {
lab=lsb10}
N 1695 -3348.75 1925 -3348.75 {
lab=lsb9}
N 2113.125 -3378.75 2153.125 -3378.75 {
lab=Vo8}
N 1695 -3228.75 1925 -3228.75 {
lab=lsb8}
N 2111.875 -3258.75 2151.875 -3258.75 {
lab=Vo9}
N 1695 -3108.75 1925 -3108.75 {
lab=lsb7}
N 2113.125 -3138.75 2153.125 -3138.75 {
lab=Vo10}
N 1695 -2991.25 1925 -2991.25 {
lab=lsb6}
N 2112.5 -3021.25 2152.5 -3021.25 {
lab=Vo11}
N 1695 -2868.75 1925 -2868.75 {
lab=lsb5}
N 2113.125 -2898.75 2153.125 -2898.75 {
lab=Vo12}
N 1695 -2751.25 1925 -2751.25 {
lab=lsb4}
N 2113.125 -2781.25 2153.125 -2781.25 {
lab=Vo13}
N 1695 -2628.75 1925 -2628.75 {
lab=lsb3}
N 2113.125 -2658.75 2153.125 -2658.75 {
lab=Vo14}
N 1695 -2511.25 1925 -2511.25 {
lab=lsb2}
N 2111.875 -2541.25 2151.875 -2541.25 {
lab=Vo15}
N 1695 -3108.75 1695 -3080 {
lab=lsb7}
N 1695 -3348.75 1695 -3320 {
lab=lsb9}
N 1695 -2301.25 1695 -2261.25 {
lab=GND}
N 1695 -2392.5 1925 -2392.5 {
lab=lsb1}
N 2111.875 -2422.5 2151.875 -2422.5 {
lab=Vo16}
N 2112.5 -2402.5 2152.5 -2402.5 {
lab=Vo16not}
N 2113.125 -3503.75 2153.75 -3503.75 {
lab=Vo7}
N 2112.5 -3483.75 2154.375 -3483.75 {
lab=Vo7not}
N 2111.875 -3621.25 2152.5 -3621.25 {
lab=Vo6}
N 1961.25 -4170 1961.25 -4158.75 {
lab=Clk}
N 1695 -4100 1695 -4068.75 {
lab=lsb15}
N 1695 -3860 1695 -3826.25 {
lab=lsb13}
N 1695 -3620 1695 -3591.25 {
lab=lsb11}
N 1695 -3141.25 1695 -3108.75 {
lab=lsb7}
N 2112.5 -2521.25 2148.75 -2521.25 {
lab=Vo15not}
N 2113.125 -2638.75 2151.875 -2638.75 {
lab=Vo14not}
N 2112.5 -2761.25 2151.25 -2761.25 {
lab=Vo13not}
N 2113.125 -2878.75 2151.25 -2878.75 {
lab=Vo12not}
N 2113.125 -3001.25 2151.875 -3001.25 {
lab=Vo11not}
N 2112.5 -3118.75 2151.875 -3118.75 {
lab=Vo10not}
N 2112.5 -3238.75 2151.875 -3238.75 {
lab=Vo9not}
N 2113.125 -3358.75 2151.25 -3358.75 {
lab=Vo8not}
N 2023.75 -4230 2044.375 -4230 {
lab=#net1}
N 2023.75 -4210 2044.375 -4210 {
lab=#net2}
N 2023.125 -4098.75 2043.75 -4098.75 {
lab=#net3}
N 2023.125 -4078.75 2043.75 -4078.75 {
lab=#net4}
N 2023.125 -3981.25 2043.75 -3981.25 {
lab=#net5}
N 2023.125 -3961.25 2043.75 -3961.25 {
lab=#net6}
N 2023.125 -3856.25 2043.75 -3856.25 {
lab=#net7}
N 2023.125 -3836.25 2043.75 -3836.25 {
lab=#net8}
N 2023.125 -3741.25 2043.75 -3741.25 {
lab=#net9}
N 2023.125 -3721.25 2043.75 -3721.25 {
lab=#net10}
N 2023.125 -3621.25 2043.75 -3621.25 {
lab=#net11}
N 2023.125 -3601.25 2043.75 -3601.25 {
lab=#net12}
N 2023.75 -3503.75 2044.375 -3503.75 {
lab=#net13}
N 2023.75 -3483.75 2044.375 -3483.75 {
lab=#net14}
N 2023.125 -3378.75 2043.75 -3378.75 {
lab=#net15}
N 2023.125 -3358.75 2043.75 -3358.75 {
lab=#net16}
N 2023.125 -3258.75 2043.75 -3258.75 {
lab=#net17}
N 2023.125 -3238.75 2043.75 -3238.75 {
lab=#net18}
N 2023.125 -3138.75 2043.75 -3138.75 {
lab=#net19}
N 2023.125 -3118.75 2043.75 -3118.75 {
lab=#net20}
N 2023.125 -3021.25 2043.75 -3021.25 {
lab=#net21}
N 2023.125 -3001.25 2043.75 -3001.25 {
lab=#net22}
N 2023.125 -2898.75 2043.75 -2898.75 {
lab=#net23}
N 2023.125 -2878.75 2043.75 -2878.75 {
lab=#net24}
N 2023.125 -2781.25 2043.75 -2781.25 {
lab=#net25}
N 2023.125 -2761.25 2043.75 -2761.25 {
lab=#net26}
N 2023.125 -2658.75 2043.75 -2658.75 {
lab=#net27}
N 2023.125 -2638.75 2043.75 -2638.75 {
lab=#net28}
N 2022.5 -2541.25 2043.125 -2541.25 {
lab=#net29}
N 2022.5 -2521.25 2043.125 -2521.25 {
lab=#net30}
N 2023.125 -2422.5 2043.75 -2422.5 {
lab=#net31}
N 2023.125 -2402.5 2043.75 -2402.5 {
lab=#net32}
N 1695 -2392.5 1695 -2360 {
lab=lsb1}
N 1695 -2660 1695 -2628.75 {
lab=lsb3}
N 1695 -2628.75 1695 -2600 {
lab=lsb3}
N 1695 -3826.25 1695 -3800 {
lab=lsb13}
N 1695 -2868.75 1695 -2840 {
lab=lsb5}
N 1695 -2900 1695 -2868.75 {
lab=lsb5}
N 1695 -2420 1695 -2392.5 {
lab=lsb1}
N 1695 -3380 1695 -3348.75 {
lab=lsb9}
N 1973.75 -3293.75 1990 -3295 {
lab=VDD}
N 1973.75 -3413.75 1990 -3420 {
lab=VDD}
N 1973.75 -3538.75 2000 -3540 {
lab=VDD}
N 1973.75 -3776.25 2000 -3780 {
lab=VDD}
N 1973.75 -3891.25 2005 -3895 {
lab=VDD}
N 1973.75 -4016.25 2000 -4025 {
lab=VDD}
N 1973.75 -4133.75 2005 -4145 {
lab=VDD}
N 1973.75 -4265 2015 -4285 {
lab=VDD}
N 1973.75 -3173.75 2020 -3170 {
lab=VDD}
N 1973.75 -3056.25 2020 -3050 {
lab=VDD}
N 1973.75 -2933.75 2015 -2935 {
lab=VDD}
N 1973.75 -2816.25 2005 -2815 {
lab=VDD}
N 1973.75 -2693.75 2010 -2690 {
lab=VDD}
N 1973.75 -2576.25 2010 -2570 {
lab=VDD}
N 1973.75 -2457.5 2010 -2455 {
lab=VDD}
N 1932.5 -4038.75 1960 -4040 {
lab=Clk}
N 1961.25 -3796.25 1961.25 -3785 {
lab=Clk}
N 1961.25 -3682.5 1961.25 -3668.75 {
lab=Clk}
N 1961.25 -3318.75 1961.25 -3305 {
lab=Clk}
N 1961.25 -3198.75 1962.5 -3182.5 {
lab=Clk}
N 1961.25 -3080 1961.25 -3070 {
lab=Clk}
N 1961.25 -2962.5 1961.25 -2950 {
lab=Clk}
N 1961.25 -2841.25 1961.25 -2827.5 {
lab=Clk}
N 1961.25 -2722.5 1961.25 -2708.75 {
lab=Clk}
N 1961.25 -2598.75 1961.25 -2588.75 {
lab=Clk}
N 1961.25 -2482.5 1961.25 -2468.75 {
lab=Clk}
N 1961.25 -2363.75 1961.25 -2340 {
lab=Clk}
N 1973.75 -3656.25 2010 -3660 {
lab=VDD}
N 1961.25 -3561.25 1961.25 -3545 {
lab=Clk}
N 1941.25 -3542.5 1961.25 -3545 {
lab=Clk}
N 1952.5 -3183.75 1962.5 -3182.5 {
lab=Clk}
N 1943.75 -3428.75 1961.25 -3443.75 {
lab=Clk}
N 1920 -3900 1961.25 -3921.25 {
lab=Clk}
C {devices/ipin.sym} 1512.5 -4150 0 0 {name=p26 lab=Vin}
C {devices/ipin.sym} 1512.5 -4120 0 0 {name=p27 lab=Vrefa}
C {devices/ipin.sym} 1512.5 -4070 0 0 {name=p28 lab=Clk}
C {devices/ipin.sym} 1512.5 -4020 0 0 {name=p29 lab=VDD}
C {devices/iopin.sym} 2440 -4050 0 0 {name=p1 lab=Vo1}
C {devices/iopin.sym} 2440 -4020 0 0 {name=p2 lab=Vo2}
C {devices/iopin.sym} 2440 -3990 0 0 {name=p5 lab=Vo3}
C {devices/iopin.sym} 2440 -3960 0 0 {name=p6 lab=Vo4}
C {devices/iopin.sym} 2440 -3930 0 0 {name=p31 lab=Vo5}
C {devices/iopin.sym} 2440 -3900 0 0 {name=p32 lab=Vo6}
C {devices/iopin.sym} 2440 -3870 0 0 {name=p33 lab=Vo7}
C {devices/iopin.sym} 2440 -3840 0 0 {name=p34 lab=Vo8}
C {devices/iopin.sym} 2440 -3810 0 0 {name=p35 lab=Vo9}
C {devices/iopin.sym} 2440 -3780 0 0 {name=p36 lab=Vo10}
C {devices/iopin.sym} 2440 -3750 0 0 {name=p37 lab=Vo11}
C {devices/iopin.sym} 2440 -3720 0 0 {name=p38 lab=Vo12}
C {devices/iopin.sym} 2440 -3690 0 0 {name=p42 lab=Vo13}
C {devices/iopin.sym} 2440 -3660 0 0 {name=p43 lab=Vo14}
C {devices/iopin.sym} 2440 -3600 0 0 {name=p44 lab=Vo16}
C {devices/iopin.sym} 2440 -3570 2 1 {name=p75 lab=Vo16not}
C {devices/iopin.sym} 2440 -3510 2 1 {name=p76 lab=Vo14not}
C {devices/iopin.sym} 2440 -3480 2 1 {name=p77 lab=Vo13not}
C {devices/iopin.sym} 2440 -3450 2 1 {name=p78 lab=Vo12not}
C {devices/iopin.sym} 2440 -3420 2 1 {name=p79 lab=Vo11not}
C {devices/iopin.sym} 2440 -3390 2 1 {name=p80 lab=Vo10not}
C {devices/iopin.sym} 2440 -3360 2 1 {name=p81 lab=Vo9not}
C {devices/iopin.sym} 2440 -3330 2 1 {name=p82 lab=Vo8not}
C {devices/iopin.sym} 2440 -3300 2 1 {name=p83 lab=Vo7not}
C {devices/iopin.sym} 2440 -3270 2 1 {name=p84 lab=Vo6not}
C {devices/iopin.sym} 2440 -3240 2 1 {name=p85 lab=Vo5not}
C {devices/iopin.sym} 2440 -3210 2 1 {name=p87 lab=Vo4not}
C {devices/iopin.sym} 2440 -3180 2 1 {name=p88 lab=Vo3not}
C {devices/iopin.sym} 2440 -3150 2 1 {name=p89 lab=Vo2not}
C {devices/iopin.sym} 2440 -3120 2 1 {name=p90 lab=Vo1not}
C {devices/iopin.sym} 2440 -3630 0 0 {name=p3 lab=Vo15}
C {devices/iopin.sym} 2440 -3540 2 1 {name=p30 lab=Vo15not}
C {devices/lab_pin.sym} 1695 -4318.75 1 0 {name=p131 sig_type=std_logic lab=Vrefa}
C {devices/lab_pin.sym} 1923.75 -4240 0 0 {name=p135 lab=Vin
}
C {devices/gnd.sym} 1973.75 -4175 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 1961.25 -4158.75 0 0 {name=p137 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 2153.125 -4230 2 0 {name=p138 sig_type=std_logic lab=Vo1}
C {devices/lab_pin.sym} 2150.625 -4210 2 0 {name=p139 sig_type=std_logic lab=Vo1not}
C {devices/lab_pin.sym} 2150 -4098.75 2 0 {name=p140 sig_type=std_logic lab=Vo2}
C {devices/lab_pin.sym} 2150.625 -4078.75 2 0 {name=p141 sig_type=std_logic lab=Vo2not}
C {devices/lab_pin.sym} 2151.875 -3981.25 2 0 {name=p142 sig_type=std_logic lab=Vo3}
C {devices/lab_pin.sym} 2152.5 -3961.25 2 0 {name=p143 sig_type=std_logic lab=Vo3not}
C {devices/lab_pin.sym} 2152.5 -3856.25 2 0 {name=p144 sig_type=std_logic lab=Vo4}
C {devices/lab_pin.sym} 2153.125 -3836.25 2 0 {name=p145 sig_type=std_logic lab=Vo4not}
C {devices/lab_pin.sym} 2152.5 -3741.25 2 0 {name=p146 sig_type=std_logic lab=Vo5}
C {devices/lab_pin.sym} 2150 -3721.25 2 0 {name=p147 sig_type=std_logic lab=Vo5not}
C {devices/lab_pin.sym} 2152.5 -3621.25 2 0 {name=p148 sig_type=std_logic lab=Vo6}
C {devices/lab_pin.sym} 2151.25 -3601.25 2 0 {name=p149 sig_type=std_logic lab=Vo6not}
C {devices/lab_pin.sym} 2153.75 -3503.75 2 0 {name=p150 sig_type=std_logic lab=Vo7}
C {devices/lab_pin.sym} 2153.125 -3483.75 2 0 {name=p151 sig_type=std_logic lab=Vo7not}
C {devices/lab_pin.sym} 2151.875 -3378.75 2 0 {name=p152 sig_type=std_logic lab=Vo8}
C {devices/lab_pin.sym} 2151.25 -3358.75 2 0 {name=p153 sig_type=std_logic lab=Vo8not}
C {devices/lab_pin.sym} 2151.875 -3258.75 2 0 {name=p154 sig_type=std_logic lab=Vo9}
C {devices/lab_pin.sym} 2151.875 -3238.75 2 0 {name=p155 sig_type=std_logic lab=Vo9not}
C {devices/lab_pin.sym} 2153.125 -3138.75 2 0 {name=p156 sig_type=std_logic lab=Vo10}
C {devices/lab_pin.sym} 2151.25 -3118.75 2 0 {name=p157 sig_type=std_logic lab=Vo10not}
C {devices/lab_pin.sym} 2151.25 -3021.25 2 0 {name=p158 sig_type=std_logic lab=Vo11}
C {devices/lab_pin.sym} 2151.875 -3001.25 2 0 {name=p159 sig_type=std_logic lab=Vo11not}
C {devices/lab_pin.sym} 2151.875 -2898.75 2 0 {name=p160 sig_type=std_logic lab=Vo12}
C {devices/lab_pin.sym} 2151.25 -2878.75 2 0 {name=p161 sig_type=std_logic lab=Vo12not}
C {devices/lab_pin.sym} 2153.125 -2781.25 2 0 {name=p162 sig_type=std_logic lab=Vo13}
C {devices/lab_pin.sym} 2150.625 -2761.25 2 0 {name=p163 sig_type=std_logic lab=Vo13not}
C {devices/lab_pin.sym} 2151.875 -2658.75 2 0 {name=p164 sig_type=std_logic lab=Vo14}
C {devices/lab_pin.sym} 2151.875 -2638.75 2 0 {name=p165 sig_type=std_logic lab=Vo14not}
C {devices/lab_pin.sym} 2151.875 -2541.25 2 0 {name=p166 sig_type=std_logic lab=Vo15}
C {devices/lab_pin.sym} 2148.75 -2521.25 2 0 {name=p167 sig_type=std_logic lab=Vo15not}
C {devices/lab_pin.sym} 2151.875 -2422.5 2 0 {name=p168 sig_type=std_logic lab=Vo16}
C {devices/lab_pin.sym} 2152.5 -2402.5 2 0 {name=p169 sig_type=std_logic lab=Vo16not}
C {Amplifiers/Comparator.sym} 1961.25 -4218.75 0 0 {name=x33}
C {devices/gnd.sym} 1675 -4250 1 0 {name=l36 lab=GND}
C {devices/gnd.sym} 1675 -4130 1 0 {name=l37 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -4130 0 0 {name=R17
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -4250 0 0 {name=R19
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -4010 1 0 {name=l38 lab=GND}
C {devices/gnd.sym} 1675 -3890 1 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3890 0 0 {name=R20
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -4010 0 0 {name=R21
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -3770 1 0 {name=l40 lab=GND}
C {devices/gnd.sym} 1675 -3650 1 0 {name=l41 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3650 0 0 {name=R22
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3770 0 0 {name=R23
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -3530 1 0 {name=l42 lab=GND}
C {devices/gnd.sym} 1675 -3410 1 0 {name=l43 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3410 0 0 {name=R24
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3530 0 0 {name=R25
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -3290 1 0 {name=l44 lab=GND}
C {devices/gnd.sym} 1675 -3170 1 0 {name=l45 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3170 0 0 {name=R26
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3290 0 0 {name=R27
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -3050 1 0 {name=l46 lab=GND}
C {devices/gnd.sym} 1675 -2930 1 0 {name=l47 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2930 0 0 {name=R28
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -3050 0 0 {name=R29
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -2810 1 0 {name=l48 lab=GND}
C {devices/gnd.sym} 1675 -2690 1 0 {name=l49 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2690 0 0 {name=R30
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2810 0 0 {name=R31
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/gnd.sym} 1675 -2570 1 0 {name=l50 lab=GND}
C {devices/gnd.sym} 1675 -2450 1 0 {name=l51 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2450 0 0 {name=R32
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2570 0 0 {name=R33
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/lab_pin.sym} 1923.75 -4108.75 0 0 {name=p170 lab=Vin
}
C {devices/gnd.sym} 1973.75 -4043.75 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} 1932.5 -4038.75 0 0 {name=p172 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -4087.5 0 0 {name=x35}
C {devices/lab_pin.sym} 1923.75 -3991.25 0 0 {name=p173 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3926.25 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} 1920 -3900 0 0 {name=p175 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 1923.75 -3866.25 0 0 {name=p225 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3801.25 0 0 {name=l70 lab=GND}
C {devices/lab_pin.sym} 1961.25 -3785 3 0 {name=p227 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3845 0 0 {name=x69}
C {devices/lab_pin.sym} 1923.75 -3751.25 0 0 {name=p230 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3686.25 0 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} 1961.25 -3668.75 3 0 {name=p232 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3730 0 0 {name=x71}
C {devices/lab_pin.sym} 1923.75 -3631.25 0 0 {name=p235 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3566.25 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 1941.25 -3542.5 0 0 {name=p237 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3610 0 0 {name=x73}
C {devices/lab_pin.sym} 1923.75 -3513.75 0 0 {name=p240 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3448.75 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} 1943.75 -3428.75 0 0 {name=p242 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3492.5 0 0 {name=x75}
C {devices/lab_pin.sym} 1923.75 -3388.75 0 0 {name=p245 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3323.75 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} 1961.25 -3305 3 0 {name=p247 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3367.5 0 0 {name=x77}
C {devices/lab_pin.sym} 1923.75 -3268.75 0 0 {name=p250 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3203.75 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 1952.5 -3183.75 0 0 {name=p252 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3247.5 0 0 {name=x79}
C {devices/lab_pin.sym} 1923.75 -3148.75 0 0 {name=p255 lab=Vin
}
C {devices/gnd.sym} 1973.75 -3083.75 0 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} 1961.25 -3070 3 0 {name=p257 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3127.5 0 0 {name=x81}
C {devices/lab_pin.sym} 1923.75 -3031.25 0 0 {name=p260 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2966.25 0 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2950 3 0 {name=p262 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -3010 0 0 {name=x83}
C {devices/lab_pin.sym} 1923.75 -2908.75 0 0 {name=p265 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2843.75 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2827.5 3 0 {name=p267 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -2887.5 0 0 {name=x85}
C {devices/lab_pin.sym} 1923.75 -2791.25 0 0 {name=p270 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2726.25 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2708.75 3 0 {name=p272 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -2770 0 0 {name=x87}
C {devices/lab_pin.sym} 1923.75 -2668.75 0 0 {name=p275 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2603.75 0 0 {name=l80 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2588.75 3 0 {name=p277 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -2647.5 0 0 {name=x89}
C {devices/lab_pin.sym} 1923.75 -2551.25 0 0 {name=p280 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2486.25 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2468.75 3 0 {name=p282 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -2530 0 0 {name=x91}
C {Amplifiers/Comparator.sym} 1961.25 -3970 0 0 {name=x93}
C {devices/gnd.sym} 1675 -2331.25 1 0 {name=l54 lab=GND}
C {sky130_fd_pr/res_high_po_1p41.sym} 1695 -2331.25 0 0 {name=R34
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=8}
C {devices/lab_pin.sym} 1923.75 -2432.5 0 0 {name=p176 lab=Vin
}
C {devices/gnd.sym} 1973.75 -2367.5 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} 1961.25 -2340 3 0 {name=p178 sig_type=std_logic lab=Clk}
C {Amplifiers/Comparator.sym} 1961.25 -2411.25 0 0 {name=x39}
C {devices/gnd.sym} 1695 -2262.5 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} 1695 -4180 0 0 {name=p4 sig_type=std_logic lab=lsb16}
C {devices/lab_pin.sym} 1695 -4055 0 0 {name=p7 sig_type=std_logic lab=lsb15}
C {devices/lab_pin.sym} 1695 -3945 0 0 {name=p8 sig_type=std_logic lab=lsb14}
C {devices/lab_pin.sym} 1695 -3815 0 0 {name=p9 sig_type=std_logic lab=lsb13}
C {devices/lab_pin.sym} 1695 -3695 0 0 {name=p10 sig_type=std_logic lab=lsb12}
C {devices/lab_pin.sym} 1695 -3580 0 0 {name=p11 sig_type=std_logic lab=lsb11}
C {devices/lab_pin.sym} 1695 -3455 0 0 {name=p12 sig_type=std_logic lab=lsb10}
C {devices/lab_pin.sym} 1695 -3335 0 0 {name=p13 sig_type=std_logic lab=lsb9}
C {devices/lab_pin.sym} 1695 -3215 0 0 {name=p14 sig_type=std_logic lab=lsb8}
C {devices/lab_pin.sym} 1695 -3095 0 0 {name=p15 sig_type=std_logic lab=lsb7}
C {devices/lab_pin.sym} 1695 -2975 0 0 {name=p16 sig_type=std_logic lab=lsb6}
C {devices/lab_pin.sym} 1695 -2855 0 0 {name=p17 sig_type=std_logic lab=lsb5}
C {devices/lab_pin.sym} 1695 -2730 0 0 {name=p18 sig_type=std_logic lab=lsb4}
C {devices/lab_pin.sym} 1695 -2610 0 0 {name=p19 sig_type=std_logic lab=lsb3}
C {devices/lab_pin.sym} 1695 -2495 0 0 {name=p20 sig_type=std_logic lab=lsb2}
C {devices/lab_pin.sym} 1695 -2380 0 0 {name=p21 sig_type=std_logic lab=lsb1}
C {StandardCells/SRlatch.sym} 1974.375 -4218.75 0 0 {name=x1}
C {StandardCells/SRlatch.sym} 1973.75 -4087.5 0 0 {name=x2}
C {StandardCells/SRlatch.sym} 1973.75 -3970 0 0 {name=x3}
C {StandardCells/SRlatch.sym} 1973.75 -3845 0 0 {name=x4}
C {StandardCells/SRlatch.sym} 1973.75 -3730 0 0 {name=x5}
C {StandardCells/SRlatch.sym} 1973.75 -3610 0 0 {name=x6}
C {StandardCells/SRlatch.sym} 1974.375 -3492.5 0 0 {name=x7}
C {StandardCells/SRlatch.sym} 1973.75 -3367.5 0 0 {name=x8}
C {StandardCells/SRlatch.sym} 1973.75 -3247.5 0 0 {name=x9}
C {StandardCells/SRlatch.sym} 1973.75 -3127.5 0 0 {name=x10}
C {StandardCells/SRlatch.sym} 1973.75 -3010 0 0 {name=x11}
C {StandardCells/SRlatch.sym} 1973.75 -2887.5 0 0 {name=x12}
C {StandardCells/SRlatch.sym} 1973.75 -2770 0 0 {name=x13}
C {StandardCells/SRlatch.sym} 1973.75 -2647.5 0 0 {name=x14}
C {StandardCells/SRlatch.sym} 1973.125 -2530 0 0 {name=x15}
C {StandardCells/SRlatch.sym} 1973.75 -2411.25 0 0 {name=x16}
C {devices/lab_pin.sym} 2015 -4285 1 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2005 -4145 1 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2000 -4025 1 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2005 -3895 1 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2000 -3780 1 0 {name=p39 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2010 -3660 1 0 {name=p40 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2000 -3540 1 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1990 -3420 1 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1990 -3295 1 0 {name=p46 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2010 -2455 2 0 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2010 -2570 2 0 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2010 -2690 2 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2005 -2815 2 0 {name=p50 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2015 -2935 2 0 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2020 -3050 2 0 {name=p52 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2020 -3170 2 0 {name=p53 sig_type=std_logic lab=VDD}
