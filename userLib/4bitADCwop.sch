v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 450 -2810 450 -2770 {
lab=#net1}
N 450 -2790 670 -2790 {
lab=#net1}
N 450 -2710 450 -2650 {
lab=#net2}
N 450 -2650 450 -2560 {
lab=#net2}
N 450 -2560 450 -2480 {
lab=#net2}
N 450 -2420 450 -2380 {
lab=#net3}
N 450 -2400 670 -2400 {
lab=#net3}
N 450 -2320 450 -2260 {
lab=#net4}
N 450 -2110 450 -2070 {
lab=#net5}
N 450 -2090 670 -2090 {
lab=#net5}
N 450 -2010 450 -1950 {
lab=#net6}
N 450 -2260 450 -2170 {
lab=#net4}
N 450 -1950 450 -1870 {
lab=#net6}
N 450 -1810 450 -1770 {
lab=#net7}
N 450 -1710 450 -1650 {
lab=#net8}
N 450 -1500 450 -1460 {
lab=#net9}
N 450 -1480 670 -1480 {
lab=#net9}
N 450 -1650 450 -1560 {
lab=#net8}
N 450 -1790 670 -1790 {
lab=#net7}
N 450 -1400 450 -1370 {
lab=#net10}
N 450 -1290 450 -1210 {
lab=#net10}
N 450 -1150 450 -1110 {
lab=#net11}
N 450 -1130 670 -1130 {
lab=#net11}
N 450 -1050 450 -990 {
lab=#net12}
N 450 -840 450 -800 {
lab=#net13}
N 450 -820 670 -820 {
lab=#net13}
N 450 -740 450 -680 {
lab=#net14}
N 450 -990 450 -900 {
lab=#net12}
N 450 -680 450 -600 {
lab=#net14}
N 450 -540 450 -500 {
lab=#net15}
N 450 -440 450 -380 {
lab=#net16}
N 450 -230 450 -190 {
lab=13lsb}
N 450 -210 670 -210 {
lab=13lsb}
N 450 -380 450 -290 {
lab=#net16}
N 450 -520 670 -520 {
lab=#net15}
N 450 -130 450 -100 {
lab=#net17}
N 450 -1370 450 -1290 {
lab=#net10}
N 450 -40 450 40 {
lab=#net17}
N 450 100 450 140 {
lab=14lsb}
N 450 200 450 260 {
lab=#net18}
N 450 410 450 450 {
lab=15lsb}
N 450 430 670 430 {
lab=15lsb}
N 450 260 450 350 {
lab=#net18}
N 450 120 670 120 {
lab=14lsb}
N 450 510 450 540 {
lab=#net19}
N 450 -100 450 -40 {
lab=#net17}
N 450 720 450 760 {
lab=msb}
N 450 740 670 740 {
lab=msb}
N 450 570 450 660 {
lab=#net19}
N 450 540 450 570 {
lab=#net19}
N 970 390 1140 390 {
lab=Vo14}
N 450 -2950 450 -2930 {
lab=#net20}
N 450 -4090 450 -4050 {
lab=#net21}
N 450 -4070 670 -4070 {
lab=#net21}
N 450 -3990 450 -3930 {
lab=#net22}
N 450 -3930 450 -3840 {
lab=#net22}
N 450 -3840 450 -3760 {
lab=#net22}
N 450 -3700 450 -3660 {
lab=#net23}
N 450 -3680 670 -3680 {
lab=#net23}
N 450 -3600 450 -3540 {
lab=#net24}
N 450 -3390 450 -3350 {
lab=#net25}
N 450 -3370 670 -3370 {
lab=#net25}
N 450 -3290 450 -3230 {
lab=#net26}
N 450 -3540 450 -3450 {
lab=#net24}
N 450 -3230 450 -3150 {
lab=#net26}
N 450 -3090 450 -3050 {
lab=#net27}
N 450 -3070 670 -3070 {
lab=#net27}
N 450 -4230 450 -4210 {
lab=Vrefa}
N 450 -2930 450 -2870 {
lab=#net20}
N 450 -2990 450 -2950 {
lab=#net20}
N 450 890 450 900 {
lab=GND}
N 450 820 450 830 {
lab=GND}
N 450 830 450 890 {
lab=GND}
N 840 80 1140 80 {
lab=Vo13}
N 850 -250 1140 -250 {
lab=Vo12}
N 840 -560 1140 -560 {
lab=Vo11}
N 850 -860 1140 -860 {
lab=Vo10}
N 840 -1170 1140 -1170 {
lab=Vo9}
N 850 -1520 1140 -1520 {
lab=Vo8}
N 840 -1830 1140 -1830 {
lab=Vo7}
N 850 -2130 1140 -2130 {
lab=Vo6}
N 840 -2440 1140 -2440 {
lab=Vo5}
N 840 -2830 1140 -2830 {
lab=Vo4}
N 840 -3110 1140 -3110 {
lab=Vo4}
N 830 -3410 1120 -3410 {
lab=Vo3}
N 840 -3720 1140 -3720 {
lab=Vo2}
N 840 -4110 1140 -4110 {
lab=Vo1}
N 590 -4160 670 -4160 {
lab=Vin}
N 590 -4230 590 -4160 {
lab=Vin}
N 750 -4230 750 -4190 {
lab=VDD}
N 750 -4050 750 -4020 {
lab=GND}
N 750 -4190 750 -4170 {
lab=VDD}
N 590 -3770 670 -3770 {
lab=Vin}
N 590 -3840 590 -3770 {
lab=Vin}
N 750 -3840 750 -3800 {
lab=VDD}
N 750 -3660 750 -3630 {
lab=GND}
N 750 -3800 750 -3780 {
lab=VDD}
N 590 -3460 670 -3460 {
lab=Vin}
N 590 -3530 590 -3460 {
lab=Vin}
N 740 -3530 740 -3490 {
lab=VDD}
N 740 -3350 740 -3320 {
lab=GND}
N 740 -3490 740 -3470 {
lab=VDD}
N 840 -3410 850 -3410 {
lab=Vo3}
N 590 -3160 670 -3160 {
lab=Vin}
N 590 -3230 590 -3160 {
lab=Vin}
N 750 -3230 750 -3190 {
lab=VDD}
N 750 -3050 750 -3020 {
lab=GND}
N 750 -3190 750 -3170 {
lab=VDD}
N 840 -3110 850 -3110 {
lab=Vo4}
N 590 -2880 670 -2880 {
lab=Vin}
N 590 -2950 590 -2880 {
lab=Vin}
N 750 -2950 750 -2910 {
lab=VDD}
N 750 -2770 750 -2740 {
lab=GND}
N 750 -2910 750 -2890 {
lab=VDD}
N 840 -2830 850 -2830 {
lab=Vo4}
N 590 -2490 670 -2490 {
lab=Vin}
N 590 -2560 590 -2490 {
lab=Vin}
N 750 -2560 750 -2520 {
lab=VDD}
N 750 -2380 750 -2350 {
lab=GND}
N 750 -2520 750 -2500 {
lab=VDD}
N 840 -2440 850 -2440 {
lab=Vo5}
N 590 -2180 670 -2180 {
lab=Vin}
N 590 -2250 590 -2180 {
lab=Vin}
N 750 -2250 750 -2210 {
lab=VDD}
N 750 -2070 750 -2040 {
lab=GND}
N 750 -2210 750 -2190 {
lab=VDD}
N 840 -2130 850 -2130 {
lab=Vo6}
N 590 -1880 670 -1880 {
lab=Vin}
N 590 -1950 590 -1880 {
lab=Vin}
N 750 -1950 750 -1910 {
lab=VDD}
N 750 -1770 750 -1740 {
lab=GND}
N 750 -1910 750 -1890 {
lab=VDD}
N 840 -1830 850 -1830 {
lab=Vo7}
N 590 -1570 670 -1570 {
lab=Vin}
N 590 -1640 590 -1570 {
lab=Vin}
N 750 -1640 750 -1600 {
lab=VDD}
N 750 -1460 750 -1430 {
lab=GND}
N 750 -1600 750 -1580 {
lab=VDD}
N 840 -1520 850 -1520 {
lab=Vo8}
N 590 -1220 670 -1220 {
lab=Vin}
N 590 -1290 590 -1220 {
lab=Vin}
N 750 -1290 750 -1250 {
lab=VDD}
N 750 -1110 750 -1080 {
lab=GND}
N 750 -1250 750 -1230 {
lab=VDD}
N 840 -1170 850 -1170 {
lab=Vo9}
N 590 -910 670 -910 {
lab=Vin}
N 590 -980 590 -910 {
lab=Vin}
N 750 -980 750 -940 {
lab=VDD}
N 750 -800 750 -770 {
lab=GND}
N 750 -940 750 -920 {
lab=VDD}
N 840 -860 850 -860 {
lab=Vo10}
N 590 -610 670 -610 {
lab=Vin}
N 590 -680 590 -610 {
lab=Vin}
N 750 -680 750 -640 {
lab=VDD}
N 750 -500 750 -470 {
lab=GND}
N 750 -640 750 -620 {
lab=VDD}
N 840 -560 850 -560 {
lab=Vo11}
N 590 -300 670 -300 {
lab=Vin}
N 590 -370 590 -300 {
lab=Vin}
N 750 -370 750 -330 {
lab=VDD}
N 750 -190 750 -160 {
lab=GND}
N 750 -330 750 -310 {
lab=VDD}
N 840 -250 850 -250 {
lab=Vo12}
N 590 30 670 30 {
lab=Vin}
N 590 -40 590 30 {
lab=Vin}
N 750 -40 750 0 {
lab=VDD}
N 750 140 750 170 {
lab=GND}
N 750 0 750 20 {
lab=VDD}
N 840 80 850 80 {
lab=Vo13}
N 590 340 670 340 {
lab=Vin}
N 590 270 590 340 {
lab=Vin}
N 750 270 750 310 {
lab=VDD}
N 750 450 750 480 {
lab=GND}
N 750 310 750 330 {
lab=VDD}
N 840 390 850 390 {
lab=Vo14}
N 590 650 670 650 {
lab=Vin}
N 590 580 590 650 {
lab=Vin}
N 750 580 750 620 {
lab=VDD}
N 750 760 750 790 {
lab=GND}
N 750 620 750 640 {
lab=VDD}
N 840 700 850 700 {
lab=Vo15}
N 850 390 970 390 {
lab=Vo14}
N 850 700 900 700 {
lab=Vo15}
C {devices/gnd.sym} 450 900 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 450 -4230 1 0 {name=p19 sig_type=std_logic lab=Vrefa}
C {devices/ammeter.sym} 450 -4180 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} 450 730 0 0 {name=p20 sig_type=std_logic lab=msb}
C {devices/lab_pin.sym} 450 420 0 0 {name=p21 sig_type=std_logic lab=15lsb
value=700}
C {devices/lab_pin.sym} 450 -220 0 0 {name=p22 sig_type=std_logic lab=13lsb}
C {devices/lab_pin.sym} 450 110 0 0 {name=p23 sig_type=std_logic lab=14lsb}
C {devices/ipin.sym} 270 -4460 0 0 {name=p26 lab=Vin}
C {devices/ipin.sym} 270 -4430 0 0 {name=p27 lab=Vrefa}
C {devices/ipin.sym} 270 -4380 0 0 {name=p28 lab=Clk}
C {devices/ipin.sym} 270 -4330 0 0 {name=p29 lab=VDD}
C {devices/res.sym} 450 -4120 0 0 {name=R1
value="100"
footprint=1206
device=resistor
m=1	}
C {devices/res.sym} 450 -4020 0 0 {name=R2
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3730 0 0 {name=R3
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3630 0 0 {name=R4
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3420 0 0 {name=R5
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3320 0 0 {name=R6
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3120 0 0 {name=R7
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -3020 0 0 {name=R8
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2840 0 0 {name=R9
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2740 0 0 {name=R10
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2450 0 0 {name=R11
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2350 0 0 {name=R12
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2140 0 0 {name=R13
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -2040 0 0 {name=R14
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1840 0 0 {name=R15
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1740 0 0 {name=R16
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1530 0 0 {name=R17
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1430 0 0 {name=R18
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1180 0 0 {name=R19
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -1080 0 0 {name=R20
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -870 0 0 {name=R21
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -770 0 0 {name=R22
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -570 0 0 {name=R23
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -470 0 0 {name=R24
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -260 0 0 {name=R25
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 -160 0 0 {name=R26
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 70 0 0 {name=R27
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 170 0 0 {name=R28
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 380 0 0 {name=R29
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 480 0 0 {name=R30
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 690 0 0 {name=R31
value="100"
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 450 790 0 0 {name=R32
value="100"
footprint=1206
device=resistor
m=1}
C {devices/iopin.sym} 1140 -4110 0 0 {name=p1 lab=Vo1}
C {devices/iopin.sym} 1140 -3720 0 0 {name=p2 lab=Vo2}
C {devices/iopin.sym} 1120 -3410 0 0 {name=p5 lab=Vo3}
C {devices/iopin.sym} 1140 -3110 0 0 {name=p6 lab=Vo4}
C {devices/iopin.sym} 1140 -2830 0 0 {name=p30 lab=Vo4}
C {devices/iopin.sym} 1140 -2440 0 0 {name=p31 lab=Vo5}
C {devices/iopin.sym} 1140 -2130 0 0 {name=p32 lab=Vo6}
C {devices/iopin.sym} 1140 -1830 0 0 {name=p33 lab=Vo7}
C {devices/iopin.sym} 1140 -1520 0 0 {name=p34 lab=Vo8}
C {devices/iopin.sym} 1140 -1170 0 0 {name=p35 lab=Vo9}
C {devices/iopin.sym} 1140 -860 0 0 {name=p36 lab=Vo10}
C {devices/iopin.sym} 1140 -560 0 0 {name=p37 lab=Vo11}
C {devices/iopin.sym} 1140 -250 0 0 {name=p38 lab=Vo12}
C {devices/iopin.sym} 1140 80 0 0 {name=p42 lab=Vo13}
C {devices/iopin.sym} 1140 390 0 0 {name=p43 lab=Vo14}
C {devices/iopin.sym} 900 700 0 0 {name=p44 lab=Vo15}
C {devices/param.sym} 70 -3710 0 0 {name=s1 value="1"}
C {devices/lab_pin.sym} 590 -4230 1 0 {name=p57 lab=Vin
}
C {devices/lab_pin.sym} 750 -4230 1 0 {name=p58 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -4020 0 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 590 -3840 1 0 {name=p4 lab=Vin
}
C {devices/lab_pin.sym} 750 -3840 1 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -3630 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 590 -3530 1 0 {name=p9 lab=Vin
}
C {devices/lab_pin.sym} 740 -3530 1 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 740 -3320 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 590 -3230 1 0 {name=p12 lab=Vin
}
C {devices/lab_pin.sym} 750 -3230 1 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -3020 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 590 -2950 1 0 {name=p15 lab=Vin
}
C {devices/lab_pin.sym} 750 -2950 1 0 {name=p16 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -2740 0 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 590 -2560 1 0 {name=p18 lab=Vin
}
C {devices/lab_pin.sym} 750 -2560 1 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -2350 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 590 -2250 1 0 {name=p39 lab=Vin
}
C {devices/lab_pin.sym} 750 -2250 1 0 {name=p40 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -2040 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 590 -1950 1 0 {name=p45 lab=Vin
}
C {devices/lab_pin.sym} 750 -1950 1 0 {name=p46 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -1740 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 590 -1640 1 0 {name=p48 lab=Vin
}
C {devices/lab_pin.sym} 750 -1640 1 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -1430 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 590 -1290 1 0 {name=p51 lab=Vin
}
C {devices/lab_pin.sym} 750 -1290 1 0 {name=p52 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -1080 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 590 -980 1 0 {name=p54 lab=Vin
}
C {devices/lab_pin.sym} 750 -980 1 0 {name=p55 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -770 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 590 -680 1 0 {name=p60 lab=Vin
}
C {devices/lab_pin.sym} 750 -680 1 0 {name=p61 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -470 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 590 -370 1 0 {name=p63 lab=Vin
}
C {devices/lab_pin.sym} 750 -370 1 0 {name=p64 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 -160 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 590 -40 1 0 {name=p66 lab=Vin
}
C {devices/lab_pin.sym} 750 -40 1 0 {name=p67 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 170 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 590 270 1 0 {name=p69 lab=Vin
}
C {devices/lab_pin.sym} 750 270 1 0 {name=p70 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 480 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 590 580 1 0 {name=p72 lab=Vin
}
C {devices/lab_pin.sym} 750 580 1 0 {name=p73 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 750 790 0 0 {name=l16 lab=GND}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 700 0 0 {name=x1}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 390 0 0 {name=x2}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 80 0 0 {name=x3}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -250 0 0 {name=x4}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -560 0 0 {name=x5}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -860 0 0 {name=x6}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -1170 0 0 {name=x7}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -1520 0 0 {name=x8}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -1830 0 0 {name=x9}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -2130 0 0 {name=x10}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -2440 0 0 {name=x11}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -2830 0 0 {name=x12}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -3110 0 0 {name=x13}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 550 -3410 0 0 {name=x14}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -3720 0 0 {name=x15}
C {dependencies/pdks/sky130B/libs.tech/xschem/userLib/5TOpamp.sym} 560 -4110 0 0 {name=x16}
